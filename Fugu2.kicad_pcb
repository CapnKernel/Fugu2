# Repository CapnKernel/Fugu2

File README.md:

View this project on [CADLAB.io](https://cadlab.io/project/28816). 

Links: [github](https://github.com/fl4p/Fugu2) | [cadlab](https://cadlab.io/project/28816) | [docs](doc/) | schematics |
IBOM | [firmware](https://github.com/fl4p/fugu-mppt-firmware)
|~ [additional documentation & resources](https://github.com/fl4p/fugu-mppt-doc)

## Gallery

|                                                       |                       |
|:---------------------------------------------------------------------------------------------------:|:---------------------------------------------------------------:|
| Small aluminium enclosure with two T130 sendust cores [fmetal](HW%20Stories/Fugu%20Metal/README.md) | on heatsink, T184 sendust core   [fheat](HW%20Stories/fheat.md) |

|                |  |
|:---------------------------------------------------------:|:-------------------------------------:|
| two T184 sendust cores   [fheat2](HW%20Stories/fheat2.md) |     [fisi](HW%20Stories/fisi.md)      |

## Specs

* Solar input voltage: 12 ~ 80V (higher voltage configurations possible, please create an issue if you need help with
  component selection)
* Battery output voltage: 12 ~ 60V (LiFePo4 4s ~ 16s)
* Max battery current: 32 A
* Efficiency
    * Vin=72 Vout=27 Iout=32A: 98.17% (measured with INA228 & Riedon
      SSA-100, [smart-shunt](https://github.com/open-pe/smart-shunt-fw))

This is inspired by [Fugu MPPT](https://www.instructables.com/DIY-1kW-MPPT-Solar-Charge-Controller/).
The design has been optimized with real life experience, considering signal noise and EMI issues,
replaced hall sensor with shunt resistor and faster switching. See the list below for more changes.

## How to build

* order PCB (or make @home)
    * 1x `Fugu2.kicad_pcb`
    * 2x `psu/buck100.kicad_pcb` (one for 3.3V and one for 12V)
    * 1x M5Stack StampS3 [direct](https://docs.m5stack.com/en/core/StampS3) [AliExpress](https://www.aliexpress.com/item/1005005199957262.html)
    * Other parts
* assemble PCBs
* build inductor
    * order core and copper wire
    * wind the coil
* flash firmware

## Design Principles

* Simplicity with minimum number of components, while keeping EMI and efficiency in mind
* Only 2-layer PCB and using mostly 0805 SMD components, so this can be made at home
* Using TO220 switches for the buck for easy maintenance
* Dense PCB design to reduces parasitic L and R

## Compared to the original design:

- Multiple input caps to increase life-time, efficiency and reduced EMI
- 2 high-side switches in parallel to reduce heat and increase efficiency
- Using ESP32 ADC to sense input voltage, INA226 for bat voltage
- Using current sense resistor with INA226 (immunity against magnetic fields, less drift)
- Current sense on the battery side (less noise, can detect bat reverse current)
- Low-side current sensing because it supports up to 60V battery voltage (for 16s lifepo4 48V batteries)
- Backflow switch on battery side (bat eFuse if sth goes wrong, can safely handle a short of the high-side switches)
- Backflow switch powered by charge pump from the HS gate driver (no extra DC-DC)
- Much higher 4 A gate drive current (previously 130mA and 1.4 A) to reduce switching losses
- Introducing RC snubber circuit to reduce EMI and MOSFET voltage stress
- TVS protection circuit
- off-board 3.3V and 12V power-supply
- USB break-out and off-board programmer (ESP PROG Header)
- Improved voltage and current sense PCB Design (voltage divider & filter caps close to ADC)
- Using LM5163 for power supply. (XL7005A explodes at surge voltages ~80V. Seems vulnerable at temps >~70°C)

## Power loss reduction

* 4A gate driver UCC21330BQDRQ1 with programmable dead-time
    * fast switching (high-side)
    * optimized dead-time, reduce free-wheeling losses (low-side)
* dense half-bridge PCB design for minimum parasitic inductance
* short and min-area gate-drive tracks for minimum gate drive inductance
* low-side rectifier Schottky barrier diode to reduce free-wheeling loss and reverse-recovery loss
* cascade of input capacitors: 220nF, 1uF, 10uF, 470uF input caps to minimize capacitor ESR-loss
    * low impedance electrolytics
* optimized coil designs
    * optimized core flux density and core power loss
    * multi-[strand](https://www.e-magnetica.pl/doku.php/strand) coil for reduced R_dc and R_ac (considering skin &
      proximity effect)

# Inductor Quick Start Guide

The magnetic core material Sendust (KoolMµ) is cheap with good availability and has good saturation characteristics and
low loss.
Manufacturers offer optimized materials, focusing on price, dc bias and core loss.
([KDM](https://semic.cz/!old/files/pdf_www/Ljf_KDM.pdf): KPH, KAM, KAH, KH)

For the coil choose isolated Copper wire made for electrical applictions commonly referred as W210 with typical
conductivity of 58.5 MS/m. Choose diameter and number of strands so that inner diameter of the toroid core has a good
usage.
Prefer multiple strands for easier winding (>2mm diameter becomes unhandy to wind) and reduced ac loss (skin & proximity
effects). Many strands (>10) increase complexity of winding. a diameter between 1 and 2mm appears to be good choice.
More copper reduces dc resistance and leakage fringing (TODO ref).

## 12V or 24V battery up to 40A

* Optimized for low loss 12V and 24V batteries, up to 40A battery current @39kHz
* Core: 2 stacked [KS184-125A](https://www.semic.info/ljf-t184-s-125a-bk/)
* Wire: Ø=1.18mm Cu (1.25mm total), W210 (Grade 2) Copper
* Winding: 10 strands, 12 turns, need 20 meter wire in total (10x 2m)
* Systematic name: 2s-KS184-125A-118cu-10s-12t
* [Micrometals analyzer](https://www.micrometals.com/design-and-applications/design-tools/inductor-analyzer/?name=&inductor_type=D&l=50&iavg=30.37&vin_rms_min=45&vin_rms_max=27&f_switching=39000.0&ambient_temp=40&max_temp_rise=50&temp_rise=1&min_l=40&part_type=A&winding=F&num_cores=2&wire_strands=10&full_ratio=0.9&min_awg=30&pct_win_fill_max_e=100&energy_cost=0.2&continuous_use=0.5&conductor_material=Cu&n=12&strandsxawg=10xAWG%252316.8&partnumber=MS-184125-2&awg=16.8)

## 48V batteries up to 20A

* Core: [KS184-125A](https://www.semic.info/ljf-t184-s-125a-bk/)
* Wire: Ø=1.63mm Cu (AWG14), W210 (Grade 2) Copper
* Winding: 4 strands, 20 turns
* Systematic name: 1s-KS184-125A-163cu-4s-20t
* [Micrometals Analyzer](https://www.micrometals.com/design-and-applications/design-tools/inductor-analyzer/?name=&inductor_type=D&l=60&iavg=15&vin_rms_min=20&vin_rms_max=55&f_switching=39000&ambient_temp=40&max_temp_rise=40&temp_rise=1&min_l=40&part_type=A&winding=F&num_cores=1&wire_strands=4&full_ratio=0.45&min_awg=14&pct_win_fill_max_e=55&energy_cost=0.2&continuous_use=0.5&conductor_material=Cu&n=19&strandsxawg=4xAWG%2314&partnumber=MS-184147-2&awg=14)

# Mosfet Selection

Use [fetlib](https://github.com/fl4p/fetlib) for an extensive parametric search and ranking by power loss estimation.
See [Toshibas Product Guide on pg. 16](https://www.mouser.com/datasheet/2/408/toshiba%20america%20electronic%20components,%20inc._bce008-1209380.pdf#page=16).

## High Side Mosfet (HS, cntrl)

- exposed to switching stress
- short switching times to lower switching losses (small Qsw) but increase potential ringing (EMI)
- low Rds_on
- body diode never conducts
- picks:
    - IPP055N08NF2SAKMA1 (80V 5.5mΩ Qsw=13nC)

## Low Side Switch (LS, sync)

- Choose a mosfet with low Q_rr ([how to compute qrr loss](https://www.ti.com/lit/ta/ssztc00/ssztc00.pdf))
    - Qrr rises with increasing temperature, current and current transient
    - Qrr ringing and loss can be reduced with external Schottky diode
      or [cascode configuration](https://www.researchgate.net/publication/378199983_Improving_the_Reverse-Recovery_Performance_of_Si_SJ-MOSFETs_with_a_Low-Voltage_GaN_HEMT_in_a_Cascode_Configuration).
- low Rds_on
- low Qgd, Qgd/Qgs (prevent self turn-on)
- low r_g (prevent self turn-on)

Current through the LS Switch always flows from source to drain (4th quadrant of V-I plane),
which makes the gate drive signal rather irrelevant. It is much easier to switch than the HS, ringing is generally
not an issue. [TI Gate Drive Fudamentals](https://www.ti.com/lit/ml/slua618a/slua618a.pdf#page=22)
Switching happens near zero voltage, as the body diode is usually already/still conducting when switching on/off.

Choose a MOSFET that is designed for synchronous rectification. Consider switch node ringing and choose a higher voltage
fet to avoid channel break-down if needed.

# Power Conversion Efficiency Optimization

To improve conversion efficiency we first need to understand where power is lost and quantify it.
For quantification we can model power loss or measure it.
There is plenty of literature about modelling power loss in a DC-DC converter.
[fetlib](https://github.com/fl4p/fetlib) can model switch loss, inductor loss and capacitor loss.

Literature: [TI slvaeq9](https://www.ti.com/lit/an/slvaeq9/slvaeq9.pdf) TODO more

The are multiple ways for power loss measurement:

- Measure temperature rise of components using a thermal imager or thermal probe. This will give you can idea where
  most power is lost. If you know the thermal resistance between a component and ambient, you can calculate the power
  loss in
  watts.
- Measure total converter power loss using power two power meters, one at the input and one the output.
- Measure component loss using a multimeter (static i2r loss)
  or [oscilloscope](https://www.tek.com/en/documents/application-note/circuit-measurement-inductors-and-transformers-oscilloscope).
  Needs careful probe calibration and de-skew.

Some points to consider:

* main losses are usually switch loss and inductor loss
* measure coil ripple current. dc core saturation can lead to significant inductance drop and extreme current peaks,
  increasing loss in capacitors and switches.
* Check coil core material loss in datasheet. Use bigger core.
* Use inductor design tool, such as
  the [micrometals designer](https://www.micrometals.com/design-and-applications/design-tools/inductor-designer/)
* Use multi strand wires to reduce AC losses (skin effect, proximity effect)
* cheap caps with higher impedance can get hot (especially C_in). Find better caps, place caps in parallel to reduce ESR
* Reduce switching times: smaller gate resistors, stronger driver. Make sure there is no severe ringing at switching
  node and at the gates. Consider using a faster Mosfet (low Qsw)
* Place Schottky diode in parallel to LS switch. this can decrease reverse-recovery loss
* Use a second HS switch in parallel (with separate gate drive resistor)
* Use short & wide PCB traces, maybe 4-layer PCB.

# Higher input voltages

* input caps
* remove PV supply diode
* bigger inductivity to keep ripple current in a reasonable level
* change mosfets HS & LS V_GS(breakdown) to 120V, 150V or 200V
* voltage sense resistors

# Water Robustness Considerations

* Add a clear varnish coat to the PCB and components (especially the current sensor circuit, Supply DCDC converters)
* Choose low R_filt for the anti-aliasing filter at the current sensor (INA226) inputs to avoid destruction of the
  chip's amplifiers.
* If using a (almost) sealed enclosure (aluminium box), add a bag silica to compensate internal humidity. When the
  converter is cooling down at night it'll suck water into the enclosure. The ESP32 WROOM metallic case is not sealed.
  Consider placing a membrane? Sticker on its breathing hole.

# Panelize PCBs

You can create a single panel of boards containing the mainboard, 2 psu and and 1 mcu head.
https://github.com/yaqwsx/KiKit/discussions/242

## KiCad design Fugu2.kicad_pcb

Board: 2 copper layers, 100.0 x 100.0 mm, 127 parts (29 on the bottom side), 62 nets.

Parts:
C1: 100nF, 25V; C_0805_2012Metric
C2, C4, C15, C24: 100n 25V; C_0805_2012Metric
C3, C25: 470n 25V; C_0805_2012Metric
C5: 2.2nF, 200V, X7S; C_1206_3216Metric
C6, C7: 100n 25V X7R; C_0805_2012Metric
C8: 2.2n 200V X7S; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9, C16, C27: 1u 100V X7S; C_0805_2012Metric
C10, C12: 470u; CP_Radial_D18.0mm_P7.50mm
C11: 470u; CP_Radial_D16.0mm_P7.50mm
C13: 47u 100V; CP_Radial_D8.0mm_P3.50mm
C14: 100n 100V; C_0805_2012Metric
C17, C18: 220n 100V X7S; C_0603_1608Metric
C19: 10u 16V; C_0805_2012Metric
C20, C23: 10n 50V; C_0805_2012Metric
C28, C29, C36, C37: 1uF, 100V, X7S; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C31, C38: 220nF, 100V, X7S; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C32, C39: 2n2 50 V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C33, C41: 56pF 50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C34, C42: 2n2 100 V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C35, C43: 22uF 25V X7R; CP_Elec_6.3x5.9
D1, D17: MSS1P4-M3/89A; D_MicroSMP_AK
D2: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D6: LESD5D5.0CT1G; D_SOD-523
D7, D10, D11, D12: SS310; D_SOD-123
D8: 1N4148W-7-F; D_SOD-123
D13: SMAJ85A; D_SMA
DZ2: BZX84-C15; SOT-23
F1: Fuse; Fuse_Blade_ATO_directSolderThin
F2: 500mA fast, 50A; Fuse_0603_1608Metric
H1: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad_TopOnly
H2, H3, H4, H5: MountingHole; MountingHole_3.2mm_M3_DIN965
J1: Conn_02x03_ESP_PROG; PinHeader_2x03_P2.54mm_Vertical
J3: USB_C_Receptacle_USB2.0_14P; USB-C-SMD_G-SWITCH_GT-USB-7010ASV
J4: MCU head; PinHeader_2x07_P2.54mm_Vertical_SMD_Pin1Left
J5: I2C; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J9: BAT; TerminalBlock_MetzConnect_Type703_RT10N02HGLU_1x02_P9.52mm_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
J10: SOLAR; TerminalBlock_MetzConnect_Type703_RT10N02HGLU_1x02_P9.52mm_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
L1: L_Iron; L_Sunlord_MWSA2213S
L2, L3: 100uH; L_Taiyo-Yuden_NR-80xx_HandSoldering
PWRGND1: TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
Q3: IPP055N08NF2SAKMA1; TO-220-3_Vertical
Q4: BSS123; SOT-23
Q5, Q6, Q7: TPH1R306PL,L1Q; Infineon_PG-TDSON-8_FL
R1: 20k; R_0805_2012Metric
R2, R3, R15, R16, R23, R41, R46: 10k; R_0805_2012Metric
R4, R6, R10: 4R7; R_0805_2012Metric
R5, R7: 0R; R_0805_2012Metric
R8, R9, R20, R34: 7k5; R_0805_2012Metric
R11: 7R5; R_1206_3216Metric
R12: 7.5; R_1206_3216Metric
R13, R14: 4k7; R_0805_2012Metric
R17, R24: 1M; R_0805_2012Metric
R18, R21: 200k; R_0805_2012Metric
R19: 20R; R_0805_2012Metric
R22: 47k; R_0805_2012Metric
R25, R27: 22R; R_0805_2012Metric
R26: 0R0005; R_2512_6332Metric_Pad2.72x3.40mm_HandSolder
R28, R29: 47k 1%; R_0805_2012Metric
R31, R32, R33: 0R; R_0603_1608Metric
R38, R42: 100k; R_0805_2012Metric
R39, R44: R_0805_2012Metric
R40, R45: 33k; R_0805_2012Metric
TH1: NCP18XH103F03RB; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TPA1: TestPoint_Pad_D1.0mm
TPHO1: TestPoint_Pad_D1.5mm
TPINH1: TestPoint_Pad_D1.0mm
TPINL1: TestPoint_Pad_D1.0mm
TPLO1: TP_PWM_LO; TestPoint_Pad_D1.5mm
TPSD1: TestPoint_Pad_D1.0mm
U1: UCC21330BQDRQ1; SOIC-16_3.9x9.9mm_P1.27mm
U2: ESP32-S3-WROOM-1
U3: INA226; VSSOP-10_3x3mm_P0.5mm
U5: USBLC6-2SC6; SOT-23-6
U6, U7: LM5163DDAR; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm_ThermalVias
bfg1: TestPoint_Pad_D1.5mm
bfs1: TestPoint_Pad_D1.5mm

Connections:
+3.3V: C42.2, C43.1, L3.2, R45.1
+3V3: C2.2, C4.2, C24.1, D2.1 (VDD), J1.2 (VDD), J4.5, J5.2, R2.1, R3.1, R13.2, R14.2, R15.2, R23.2, TH1.1, U1.3 (VCCI), U1.8 (VCCI), U2.2 (3V3), U3.6 (VS)
+12V: C7.2, C34.2, C35.1, L2.2, R19.2, R40.1, U1.16 (VDDA)
/GateDrive/HI: D1.1 (K), D8.2 (A), D17.1 (K), R4.1, R6.1, TPHO1.1, U1.10 (OUTB)
/GateDrive/LO: R10.1, TPLO1.1, U1.15 (OUTA)
/PowerSupply/Vusb: D7.2 (A), J3.VBUS, U5.5 (VBUS)
/backflow/BFLOWS: C10.1, L1.2, Q5.3 (D), Q6.3 (D), Q7.3 (D)
/snubber/SW: R11.1, R12.2
/uC/ADC_Vin: C15.1, D6.1 (K), J4.9, R18.1, R20.2, U2.4 (GPIO4/TOUCH4/ADC1_CH3)
/uC/ALERT: J4.6, R15.1, TPA1.1, U2.34 (MTDI/GPIO41/CLK_OUT1), U3.3 (~Alert)
/uC/BFlowSD: J4.8, Q4.1 (G), R23.1, U2.33 (MTDO/GPIO40/CLK_OUT2)
/uC/EN: C3.1, J1.1 (EN), R2.2, U2.3 (EN)
/uC/INH: J4.12, R32.1, TPINH1.1, U2.23 (GPIO21)
/uC/INL: J4.10, R31.1, TPINL1.1, U2.22 (GPIO14/TOUCH14/ADC2_CH3/FSPIWP/FSPIDQS/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)
/uC/IO0: J1.6 (IO0), R3.2, U2.27 (GPIO0/BOOT)
/uC/LED: D2.4 (DIN), J4.1, U2.39 (GPIO1/TOUCH1/ADC1_CH0)
/uC/NTC: J4.13, R16.2, TH1.2, U2.12 (GPIO8/TOUCH8/ADC1_CH7/SUBSPICS1)
/uC/RX: J1.5 (RXD), U2.36 (U0RXD/GPIO44/CLK_OUT2)
/uC/SCL: J4.3, J5.4, R14.1, U2.38 (GPIO2/TOUCH2/ADC1_CH1), U3.5 (SCL)
/uC/SD: J4.14, R33.1, TPSD1.1, U2.24 (GPIO47/SPICLK_P/SUBSPICLK_P_DIFF)
/uC/SDA: J4.4, J5.3, R13.1, U2.35 (MTMS/GPIO42), U3.4 (SDA)
/uC/TX: J1.3 (TXD), U2.37 (U0TXD/GPIO43/CLK_OUT1)
/uC/USB_N: J3.D-, U2.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-), U5.1 (I/O1), U5.6 (I/O1)
/uC/USB_P: J3.D+, U2.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+), U5.4 (I/O2)
BT+: F1.2, J9.2, R28.2
Bat+: C20.2, D12.2 (A), DZ2.1 (A), F1.1, Q5.1 (S), Q6.1 (S), Q7.1 (S), R24.1, bfs1.1
BuckGND: C1.1, C7.1, C9.2, C10.2, C11.2, C12.2, C14.1, C16.2, C17.2, C18.2, C27.2, J10.2, PWRGND1.1, R8.1, R17.1, R25.2, R26.1, U1.14 (VSSA)
GND: C1.2, C2.1, C3.2, C4.1, C13.2, C15.2, C23.2, C24.2, C28.2, C29.2, C31.2, C35.2, C36.2, C37.2, C38.2, C43.2, D2.3 (VSS), D6.2 (A), D13.2 (A), J1.4 (GND), J3.GND, J3.SHIELD, J4.2, J4.7, J5.1, J5.MP (MountPin), J9.1, Q4.2 (S), R1.2, R16.1, R20.1, R26.2, R27.2, R29.1, R38.2, R41.2, R42.2, R46.2, U1.4 (GND), U2.1 (GND), U2.16 (GPIO46), U2.40 (GND), U2.41 (GND), U3.1 (A1), U3.2 (A0), U3.7 (GND), U5.2 (GND), U6.1 (GND), U6.9 (EP), U7.1 (GND), U7.9 (EP)
unnamed: C5.2, R12.1
unnamed: C8.1, R11.2
unnamed: C14.2, H1.1, R17.2
unnamed: C33.2, C34.1, R39.2
unnamed: C41.2, C42.1, R44.2
unnamed: D1.2 (A), R7.2
unnamed: D8.1 (K), R21.2
unnamed: D10.2 (A), R19.1
unnamed: C6.2, C19.1, D10.1 (K), U1.11 (VDDB)
unnamed: D11.1 (K), D12.1 (K), F2.1
unnamed: C13.1, C28.1, C29.1, C31.1, C36.1, C37.1, C38.1, D7.1 (K), D13.1 (K), F2.2, U6.2 (VIN), U6.3 (EN/UVLO), U7.2 (VIN), U7.3 (EN/UVLO)
unnamed: D17.2 (A), R5.2
unnamed: C20.1, DZ2.3 (K), Q5.2 (G), Q6.2 (G), Q7.2 (G), R21.1, R22.2, R24.2, bfg1.1
unnamed: R4.2, R7.1, R9.2
unnamed: R8.2, R10.2
unnamed: Q3.1 (G), R5.1, R6.2, R34.2
unnamed: Q4.3 (D), R22.1
unnamed: R33.2, U1.5 (DIS)
unnamed: R1.1, U1.6 (DT)
unnamed: R31.2, U1.1 (INA)
unnamed: R32.2, U1.2 (INB)
unnamed: C23.1, R28.1, R29.2, U3.8 (Vbus)
unnamed: C25.1, R25.1, U3.10 (Vin+)
unnamed: C25.2, R27.1, U3.9 (Vin-)
unnamed: C32.1, U6.7 (BST)
unnamed: C33.1, R40.2, R41.1, U6.5 (FB)
unnamed: R38.1, U6.4 (RON)
unnamed: C32.2, L2.1, R39.1, U6.8 (SW)
unnamed: C39.1, U7.7 (BST)
unnamed: C41.1, R45.2, R46.1, U7.5 (FB)
unnamed: R42.1, U7.4 (RON)
unnamed: C39.2, L3.1, R44.1, U7.8 (SW)
SW: C6.1, C19.2, L1.1, Q3.3 (S), R9.1, R34.1, U1.9 (VSSB)
Solar+: C5.1, C9.1, C11.1, C12.1, C16.1, C17.1, C18.1, C27.1, D11.2 (A), J10.1, Q3.2 (D), R18.2

## Commit log

2025-07-07 Saved files with KiCad 9
2025-07-07 Untangled two wires
2025-10-08 First cut, with refactored schematic (PCB now busted, it's a WIP)
2025-12-04 Added local footprint and 3D model library
2025-12-04 Mega-cleanup
2025-12-04 Remove mcu-head
2025-12-04 Removed parts from open-pe
2025-12-04 Increased resistor sizes from 0603 to 0805
2025-12-04 We don't need panelisation any more because it's one PCB
2025-12-15 Added value for fuse (comes from upstream)
2025-12-15 Fixed orientation of backflow MOSFETs (thanks Fl4p!)
